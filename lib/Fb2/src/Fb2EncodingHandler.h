#pragma once

#include <expat.h>

#include <cctype>
#include <cstring>

// clang-format off

// Windows-1251 (CP1251) bytes 0x80-0xFF → Unicode codepoints
inline constexpr int kWindows1251High[128] = {
    0x0402, 0x0403, 0x201A, 0x0453, 0x201E, 0x2026, 0x2020, 0x2021,  // 80-87
    0x20AC, 0x2030, 0x0409, 0x2039, 0x040A, 0x040C, 0x040B, 0x040F,  // 88-8F
    0x0452, 0x2018, 0x2019, 0x201C, 0x201D, 0x2022, 0x2013, 0x2014,  // 90-97
       -1,  0x2122, 0x0459, 0x203A, 0x045A, 0x045C, 0x045B, 0x045F,  // 98-9F
    0x00A0, 0x040E, 0x045E, 0x0408, 0x00A4, 0x0490, 0x00A6, 0x00A7,  // A0-A7
    0x0401, 0x00A9, 0x0404, 0x00AB, 0x00AC, 0x00AD, 0x00AE, 0x0407,  // A8-AF
    0x00B0, 0x00B1, 0x0406, 0x0456, 0x0491, 0x00B5, 0x00B6, 0x00B7,  // B0-B7
    0x0451, 0x2116, 0x0454, 0x00BB, 0x0458, 0x0405, 0x0455, 0x0457,  // B8-BF
    0x0410, 0x0411, 0x0412, 0x0413, 0x0414, 0x0415, 0x0416, 0x0417,  // C0-C7
    0x0418, 0x0419, 0x041A, 0x041B, 0x041C, 0x041D, 0x041E, 0x041F,  // C8-CF
    0x0420, 0x0421, 0x0422, 0x0423, 0x0424, 0x0425, 0x0426, 0x0427,  // D0-D7
    0x0428, 0x0429, 0x042A, 0x042B, 0x042C, 0x042D, 0x042E, 0x042F,  // D8-DF
    0x0430, 0x0431, 0x0432, 0x0433, 0x0434, 0x0435, 0x0436, 0x0437,  // E0-E7
    0x0438, 0x0439, 0x043A, 0x043B, 0x043C, 0x043D, 0x043E, 0x043F,  // E8-EF
    0x0440, 0x0441, 0x0442, 0x0443, 0x0444, 0x0445, 0x0446, 0x0447,  // F0-F7
    0x0448, 0x0449, 0x044A, 0x044B, 0x044C, 0x044D, 0x044E, 0x044F,  // F8-FF
};

// KOI8-R bytes 0x80-0xFF → Unicode codepoints
inline constexpr int kKoi8RHigh[128] = {
    0x2500, 0x2502, 0x250C, 0x2510, 0x2514, 0x2518, 0x251C, 0x2524,  // 80-87
    0x252C, 0x2534, 0x253C, 0x2580, 0x2584, 0x2588, 0x258C, 0x2590,  // 88-8F
    0x2591, 0x2592, 0x2593, 0x2320, 0x25A0, 0x2219, 0x221A, 0x2248,  // 90-97
    0x2264, 0x2265, 0x00A0, 0x2321, 0x00B0, 0x00B2, 0x00B7, 0x00F7,  // 98-9F
    0x2550, 0x2551, 0x2552, 0x0451, 0x2553, 0x2554, 0x2555, 0x2556,  // A0-A7
    0x2557, 0x2558, 0x2559, 0x255A, 0x255B, 0x255C, 0x255D, 0x255E,  // A8-AF
    0x255F, 0x2560, 0x2561, 0x0401, 0x2562, 0x2563, 0x2564, 0x2565,  // B0-B7
    0x2566, 0x2567, 0x2568, 0x2569, 0x256A, 0x256B, 0x256C, 0x00A9,  // B8-BF
    0x044E, 0x0430, 0x0431, 0x0446, 0x0434, 0x0435, 0x0444, 0x0433,  // C0-C7
    0x0445, 0x0438, 0x0439, 0x043A, 0x043B, 0x043C, 0x043D, 0x043E,  // C8-CF
    0x043F, 0x044F, 0x0440, 0x0441, 0x0442, 0x0443, 0x0436, 0x0432,  // D0-D7
    0x044C, 0x044B, 0x0437, 0x0448, 0x044D, 0x0449, 0x0447, 0x044A,  // D8-DF
    0x042E, 0x0410, 0x0411, 0x0426, 0x0414, 0x0415, 0x0424, 0x0413,  // E0-E7
    0x0425, 0x0418, 0x0419, 0x041A, 0x041B, 0x041C, 0x041D, 0x041E,  // E8-EF
    0x041F, 0x042F, 0x0420, 0x0421, 0x0422, 0x0423, 0x0416, 0x0412,  // F0-F7
    0x042C, 0x042B, 0x0417, 0x0428, 0x042D, 0x0429, 0x0427, 0x042A,  // F8-FF
};

// clang-format on

inline bool encodingNameEquals(const char* name, const char* target) {
  while (*name && *target) {
    char a = static_cast<char>(tolower(static_cast<unsigned char>(*name)));
    char b = *target;
    if (a == '-' || a == '_') {
      name++;
      continue;
    }
    if (b == '-' || b == '_') {
      target++;
      continue;
    }
    if (a != b) return false;
    name++;
    target++;
  }
  while (*name == '-' || *name == '_') name++;
  while (*target == '-' || *target == '_') target++;
  return *name == '\0' && *target == '\0';
}

inline void fillEncodingMap(XML_Encoding* info, const int* highTable) {
  for (int i = 0; i < 128; i++) info->map[i] = i;
  for (int i = 0; i < 128; i++) info->map[128 + i] = highTable[i];
  info->data = nullptr;
  info->convert = nullptr;
  info->release = nullptr;
}

inline int XMLCALL fb2UnknownEncodingHandler(void*, const XML_Char* name, XML_Encoding* info) {
  if (encodingNameEquals(name, "windows-1251") || encodingNameEquals(name, "cp1251")) {
    fillEncodingMap(info, kWindows1251High);
    return XML_STATUS_OK;
  }
  if (encodingNameEquals(name, "koi8-r") || encodingNameEquals(name, "koi8r")) {
    fillEncodingMap(info, kKoi8RHigh);
    return XML_STATUS_OK;
  }
  return XML_STATUS_ERROR;
}

